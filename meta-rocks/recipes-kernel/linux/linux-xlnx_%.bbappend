FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-feature-adapt-xxv-ethernet-driver-for-open-source-ve.patch"
