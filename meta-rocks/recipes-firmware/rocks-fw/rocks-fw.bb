SUMMARY = "Custom firmware for the k26 starter kits"

include kria-custom-firmware.inc
inherit update-alternatives

FW_DIR = "rocks-fw"
